Commit message: wheels now movable joints

File: urdf/edumip_my_robot.urdf (robot description, URDF)
Before this commit: robot EduMIP, 3 links, 2 joints
Joints:
- joint wheelL_joint: axis (none) -> 0 1 0; type fixed -> continuous
- joint wheelR_joint: axis (none) -> 0 1 0; type fixed -> continuous
